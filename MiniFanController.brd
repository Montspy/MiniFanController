# Repository Montspy/MiniFanController

File README.md:

# MiniFanController
A 2 channel temperature-controlled PWM fan controller

## EAGLE design MiniFanController.brd

Parts:
J1, J2, J3: MOLEX_47053-1000MOLEX_47053-1000_0_0; MOLEX_47053-1000_0
J5: TSW-102-07-G-S; TSW-102-XX-G-S
J6: MA04-1
Q1, Q3, Q4, Q6: MICRO_COMMERCIAL_MMSS8050-L-TPMICRO_COMMERCIAL_MM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; MICRO_COMMERCIAL_MMSS8050-L-TP_0
Q2, Q5: DIODES_INC_DMP3099L-13DIODES_INC_DMP3099L-13_0_2; DIODES_INC_DMP3099L-13_2
R1, R6: 100k; R0603
R2, R4, R5, R7, R9, R10, R12, R13, R14, R15: 2.2k; R0603
R3, R8: 1k; R0603
R11: 10k; R0603
U1: NANO_FOOTPRINT; NANO

Connections:
12V_EN1: R14.1, U1.8 (D5)
12V_EN2: R15.1, U1.9 (D6)
12V_FAN1: J2.2, Q2.3 (D)
12V_FAN2: J3.2, Q5.3 (D)
+3V3: R11.2, U1.17 (3V3), U1.18 (AREF)
+5V: J6.2, R2.2, R7.2, U1.27 (5V)
+12V: J1.2, Q2.2 (S), Q5.2 (S), R3.2, R8.2, U1.30 (VIN)
GND: J1.1, J2.1, J3.1, J5.2, J6.1, Q1.2 (E), Q3.2 (E), Q4.2 (E), Q6.2 (E), R1.1, R4.1, R5.1, R6.1, R9.1, R10.1, U1.4 (GND), U1.29 (GND)
unnamed: Q5.1 (G), Q6.3 (C), R8.1
unnamed: Q2.1 (G), Q3.3 (C), R3.1
unnamed: Q1.1 (B), R5.2, R12.2
unnamed: Q4.1 (B), R10.2, R13.2
unnamed: Q3.1 (B), R4.2, R14.2
unnamed: Q6.1 (B), R9.2, R15.2
PWM1: R12.1, U1.12 (D9)
PWM2: R13.1, U1.13 (D10)
PWM_FAN1: J2.4, Q1.3 (C), R1.2, U1.15 (D12)
PWM_FAN2: J3.4, Q4.3 (C), R6.2, U1.16 (D13)
PWM_MB: J1.4
SCL: J6.3, U1.24 (A5/SCL)
SDA: J6.4, U1.23 (A4/SDA)
TACH_FAN1: J2.3, R2.1, U1.5 (D2)
TACH_FAN2: J3.3, R7.1, U1.6 (D3)
TACH_MB: J1.3
TEMP_IN: J5.1, R11.1, U1.20 (A1)

Notes on the sheet:
INPUT
OUTPUT
PWM drive and sense
Tach sense
12V switching for 3pin

Board: 2 copper layers, 17.8 x 51.4 mm, 27 parts (4 on the bottom side), 23 nets.

## Commit log

2020-12-21 First prototype
2020-12-21 PDF schematics added
2020-12-31 v2 commit. Added current limiting base resistors (oops)
2021-01-04 Fix PMOS Source-Drain mixup

Notices in the files:
parts and their libraries:
SparkFun-Boards: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
